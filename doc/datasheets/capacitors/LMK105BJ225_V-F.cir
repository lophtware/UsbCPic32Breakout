* LMK105BJ225_V-F     SPICE MODEL  ( General Type )
*--------------------------------------------------------------------------------------------------------
* Model Generated by TAIYO YUDEN Corporation (http://www.ty-top.com)
* Version 1.0
* TAIYO YUDEN Control No. 170508_140220
*--------------------------------------------------------------------------------------------------------
*
* Products Name : Multilayer Ceramic Capacitors
*
* Characteristics :
*     Capacitance : 2.2 uF , Rated Voltage : 10V , TCC : X5R
*     Case Size : 1.0 x 0.5 / 0.039 x 0.02 [mm/inch] , Thickness : 0.5 / 0.02 [mm/inch]
*     (Conditions: Temperature = 25 degC , DC Bias Current/Voltage = 0A / 0V)
*
* Frequency Range : 40Hz - 3GHz
*
* External Node Assignments :
*
*  1  o---| |---o  2
*
*--------------------------------------------------------------------------------------------------------
.SubCkt LMK105BJ225_V-F 1 2
****************************
C0 1 110 1.6628u
Cm 1 101 0.30883u
C1 101 102 0.55231u
Rc1 101 102 1.908k
C2 102 103 0.23362u
Rc2 102 103 121.91
C3 103 110 0.1282u
Rc3 103 110 9.8665
C2m 1 301 0.33684u
C21 301 302 1.5419u
Rc21 301 302 3.5852k
C22 302 303 2.1628u
Rc22 302 303 2.5122k
C23 303 304 1.523u
Rc23 303 304 3.2467k
C24 304 305 0.50398u
Rc24 304 305 302.45
C25 305 306 0.78338u
Rc25 305 306 164.84
C26 306 307 1.7674u
Rc26 306 307 70.993
C27 307 308 0.2764u
Rc27 307 308 26.173
C28 308 309 0.35852u
Rc28 308 309 16.417
C29 309 110 0.011888u
Rc29 309 110 2.1029
Rp0 1 110 45.4545454545455Meg
L0 110 120 0.22706n
Lm 120 130 0.14172n
L1 120 121 0.035781n
RL1 121 130 0.90671
L2 120 122 0.1911n
RL2 122 130 47.884m
L3 120 123 0.20921n
RL3 123 130 0.91933
CR 120 124 0.14927u
LR 124 125 0.047673n
RR 125 130 0.12443
CL 130 140 2.283p
LL 130 140 0.12242n
RL 130 140 94.143
Rs 140 2 4.0373m
****************************
.ends
