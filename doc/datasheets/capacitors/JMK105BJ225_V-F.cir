* JMK105BJ225_V-F     SPICE MODEL  ( General Type )
*--------------------------------------------------------------------------------------------------------
* Model Generated by TAIYO YUDEN Corporation (http://www.ty-top.com)
* Version 1.0
* TAIYO YUDEN Control No. 170508_140725
*--------------------------------------------------------------------------------------------------------
*
* Products Name : Multilayer Ceramic Capacitors
*
* Characteristics :
*     Capacitance : 2.2 uF , Rated Voltage : 6.3V , TCC : X5R
*     Case Size : 1.0 x 0.5 / 0.039 x 0.02 [mm/inch] , Thickness : 0.5 / 0.02 [mm/inch]
*     (Conditions: Temperature = 25 degC , DC Bias Current/Voltage = 0A / 0V)
*
* Frequency Range : 40Hz - 3GHz
*
* External Node Assignments :
*
*  1  o---| |---o  2
*
*--------------------------------------------------------------------------------------------------------
.SubCkt JMK105BJ225_V-F 1 2
****************************
C0 1 110 1.5794u
Cm 1 101 0.32723u
C1 101 102 1.4426u
Rc1 101 102 1.1812k
C2 102 103 0.4579u
Rc2 102 103 156.82
C3 103 110 0.37986u
Rc3 103 110 0.41703
C2m 1 301 0.42295u
C21 301 302 4.429u
Rc21 301 302 894.13
C22 302 303 3.6889u
Rc22 302 303 886.05
C23 303 304 2.5828u
Rc23 303 304 1.1687k
C24 304 305 2.6702u
Rc24 304 305 120.52
C25 305 306 1.0927u
Rc25 305 306 291.64
C26 306 307 1.284u
Rc26 306 307 14.026
C27 307 308 0.71053u
Rc27 307 308 16.824
C28 308 309 0.19495u
Rc28 308 309 8.1736
C29 309 110 0.018335u
Rc29 309 110 0.65227
Rp0 1 110 45.4545454545455Meg
L0 110 120 0.2298n
Lm 120 130 0.1417n
L1 120 121 0.029719n
RL1 121 130 0.43063
L2 120 122 0.062951n
RL2 122 130 0.13185
L3 120 123 1.6892n
RL3 123 130 2.6406
CR 120 124 0.20805u
LR 124 125 0.33758n
RR 125 130 52.782m
CL 130 140 2.3039p
LL 130 140 0.12418n
RL 130 140 123.11
Rs 140 2 6.7929m
****************************
.ends
